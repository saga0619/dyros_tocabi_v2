Commit message: hand urdf tuned

File: tocabi_description/robots/dyros_tocabi_with_redhand_qb.urdf (robot description, URDF)
Before this commit: robot dyros_tocabi_description, 36 links, 35 joints
Links:
- link L_Wrist2_Link: mass 0.6 -> 0.350
- link R_Wrist2_Link: mass 0.6 -> 0.350
