Commit message: rx_minimize

File: tocabi_description/robots/dyros_tocabi_with_redhands.urdf (robot description, URDF)
Before this commit: robot dyros_tocabi_description, 36 links, 35 joints
Links:
- link Head_Link: mass 0.006332 -> 1.006332
